# Keil uVision project lwip_ch390d.uvprojx, settings and files
target lwip_ch390d (5060960::V5.06 update 7 (build 960)::.\armcc_v5_cracked)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: lwip_ch390d_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Inc;                                       ../Drivers/STM32G0xx_HAL_Driver/Inc;                                       ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;                                       ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;                                       ../Drivers/CMSIS/Include;                                       ..\..\systick;                                       ..\..\ch390d;                                       ..\..\lwip-2_2_0\src\apps;                                       ..\..\lwip-2_2_0\src\include;                                       ..\..\lwip-2_2_0\src\include\arch;                                       ..\..\lwip-2_2_0\src\include\lwip;                                       ..\..\tcpudp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User
    ../Src/: main.c gpio.c rtc.c spi.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group ch390d
    ../../ch390d/: CH390.c CH390_Interface.c
  group lwip_2.2.0
    ../../lwip-2_2_0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../lwip-2_2_0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../lwip-2_2_0/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../lwip-2_2_0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../lwip-2_2_0/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c ethernetif.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group delay
    ../../systick/: delay.c
  group tcp
    ../../tcpudp/: tcp_echo.c udp_echo.c
software components: CMSIS:CORE 4.3.0
